# Keil uVision project PY063xx_Flash.uvprojx, settings and files
target PY063xx_32 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: PY32F072xB Puya
  pack: Puya.PY32F0xx_DFP.1.2.4
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: PY063xx_32
  AfterMake: cmd.exe /C copy "!L" ".\Out\@L.FLM"
  c flags: Optim=2 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: FLASH_MEM PY063xx_32
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
target PY063xx_64 (6220000::V6.22::ARMCLANG)
  device: PY32F072xB Puya
  pack: Puya.PY32F0xx_DFP.1.2.12
  cpu: as above
  output: PY063xx_64
  AfterMake: cmd.exe /C copy "!L" ".\Out\@L.FLM"
  c flags: Optim=2 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: FLASH_MEM PY063xx_64
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target PY063xx_96 (6220000::V6.22::ARMCLANG)
  device: PY32F072xB Puya
  pack: Puya.PY32F0xx_DFP.1.2.12
  cpu: as above
  output: PY063xx_96
  AfterMake: cmd.exe /C copy "!L" ".\Out\@L.FLM"
  c flags: Optim=2 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: FLASH_MEM PY063xx_96
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target PY063xx_128 (6220000::V6.22::ARMCLANG)
  device: PY32F072xB Puya
  pack: Puya.PY32F0xx_DFP.1.2.12
  cpu: as above
  output: PY063xx_128
  AfterMake: cmd.exe /C copy "!L" ".\Out\@L.FLM"
  c flags: Optim=2 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: FLASH_MEM PY063xx_128
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target FLASH_OB (6220000::V6.22::ARMCLANG)
  device: PY32F072xB Puya
  pack: Puya.PY32F0xx_DFP.1.2.12
  cpu: as above
  output: PY063xx_OB
  AfterMake: cmd.exe /C copy "!L" ".\Out\@L.FLM"
  c flags: Optim=2 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: Flash_OB,PY063xx_128
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
software components: CMSIS:CORE 5.6.0, CMSIS:CORE 6.1.0
