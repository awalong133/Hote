# Keil uVision project Hote.uvprojx, settings and files
target Hote (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: PY32F002Bx5 Puya
  pack: Puya.PY32F0xx_DFP.1.2.15
  cpu: IRAM(0x20000000,0x00000C00) IROM(0x08000000,0x00006000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Hote +hex
  c flags: OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c include: ..\Inc;..\Src;..\Src\ExtDevice;..\Src\ExtDevice\Lcd
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x6000
  memory RVCT9: RAM 0x20000000 size 0xc00
  group App
    ../Inc/: PinFun.h Hote.h
    ../Src/: main.c
    ./: Hote_PY32F0.lib
  group ExtDevice
    ../Src/ExtDevice/: Mpu6050.c Mpu6050.h
    ../Src/ExtDevice/Lcd/: fonts.h LCD_St7789.c LCD_St7789.h
  group Doc
    ../: readme.md
